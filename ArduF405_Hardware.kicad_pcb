# Repository KingFish233/ArduF405_Hardware

## KiCad design ArduF405_Hardware.kicad_pcb

Parts:
BOOT1: TD-1183SN-1.5H(3x2.5); 3x2.5PushButton
C1, C3, C16, C18: 0.1uF(0402); C_0402_1005Metric
C2, C19: 10uF(0603 35V 20%); C_0603_1608Metric
C4, C8, C20: 1uF(0402 35V 10%); C_0402_1005Metric
C5, C6, C9: 1uF(0402 16V 10%); C_0402_1005Metric
C7, C21: 100nF(0603 10V 10%); C_0603_1608Metric
C10: 100uF; CP_Elec_6.3x7.7
C11: 100nF(0201 16V 10%); C_0201_0603Metric
C12, C13: 22uF(0805 35V 20%); C_0805_2012Metric
C14, C15: 1uF(0402 10V 10%); C_0402_1005Metric
C17, C22: 100nF(0603 25V 10%); C_0603_1608Metric
C23, C24, C25, C44, C45: 22uF(0603 16V); C_0603_1608Metric
C26: 100nF(0603 10.0V 10%); C_0603_1608Metric
C27, C28: 2.2uF(0402 6.3V 10%); C_0402_1005Metric
C29: 4.7uF(0402 10V); C_0402_1005Metric
C30, C31, C32, C33, C34, C35, C36, C38, C39, C40, C41, C42, C43: 100nF(0402 16.0V 10%); C_0402_1005Metric
C37: 15pF (0603 50V 5%); C_0603_1608Metric
D1: PESD12VV1BL; PESD12VV1BL_315
D2, D4: PESD5V0F1BL
D3: SMF30CA(30V); D_SOD-123F
D5, D7: DSS34(3A 500mV); D_SOD-123F
D6: BZX584C9V1; D_SOD-523
D8: LED_Red; LED_0603_1608Metric
D9, D10: LED_blue; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_4.3mm_M4_DIN965_Pad
J1: USB_C_Receptacle_USB2.0; USB_C_Small
J2: CAM; 01x03_MP_sh1.0_Hori
J3: GPS; 1x06-1MP_P1.00mm_Horizontal
J4: VTX; 01x05_MP_sh1.0_Hori
J5: DJI O4; 1x06-1MP_P1.00mm_Horizontal
J6: ESC; 01x08_MP_sh1.0_Hori
J7: Upper computer connector/RC input; 01x04_MP_sh1.0_Hori
J8: ESC_2; 01x08_MP_sh1.0_Hori
J9: USART_1; 01x04_MP_sh1.0_Hori
J10: Micro_SD_Card; TF-SMD_TF-021B-H265
J12: UART_4; 01x04_MP_sh1.0_Hori
L1, L2: 10uH(0420)(78438357100); Inductor_0420
Q1: AP40P05; SOT-23
R1, R2: 5.1kR(0201); R_0201_0603Metric
R3, R5: 1MR(0402 50V); R_0402_1005Metric
R4, R6: 100kR(0603 25V); R_0603_1608Metric
R7: 100kR(0603 50V); R_0603_1608Metric
R8, R10: 20R(0603 25V); R_0603_1608Metric
R9, R12: 51kR(0603 25V); R_0603_1608Metric
R11: 7.68kR(0603 25V); R_0603_1608Metric
R13, R19: 41.2kR(0603 25V); R_0603_1608Metric
R14: 200.0kR(0603 50V 1%); R_0603_1608Metric
R15: 22.0kR(0603 50V 1%); R_0603_1608Metric
R16, R17: 75R(0603 50V); R_0603_1608Metric
R18, R20, R21, R22: 3.6kR(0603 25V); R_0603_1608Metric
R27, R28, R29, R30, R31, R32, R33, R34, R35, R36: 10kR(0603); R_0603_1608Metric
TP1: 24V_TP; MiniTP
U1, U9: MP9943GQ-Z
U2, U3: RT9013-33GB
U4: STM32F405RGTx; LQFP-64_10x10mm_P0.5mm
U5: BMI270; LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y
U6: AT7456E; HTSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP2.85x5.4mm
U7: W25Q128JVS; SOIC-8_5.3x5.3mm_P1.27mm
U8: SPL06; Bosch_LGA-8_2x2.5mm_P0.65mm_ClockwisePinNumbering
U19: SN74LVC1G86DCKR; DCK5
Y1: YXC 0T252016MJBA4SL; Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm
Y2: YXC_XG1EL89CSI-111YLC-27M 27MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm_HandSoldering

Connections:
/BATT_CURRENT_SENS: J6.5, J8.5, U4.25 (PC5)
/BATT_VOLTAGE_SENS: C36.2, R14.2, R15.1, U4.24 (PC4)
/FLASH_CS: U4.2 (PC13), U7.1 (~CS)
/I2C1_SCL: J3.5, R32.2, U4.61 (PB8), U8.4 (SCL); also elsewhere on the board
/I2C1_SDA: J3.6, R31.2, U4.59 (PB7), U8.3 (SDA); also elsewhere on the board
/IMU_CS: U4.3 (PC14), U5.12 (CSB)
/LED_0: D9.2 (A), U4.46 (PA13)
/LED_1: D10.2 (A), U4.49 (PA14)
/OSD_CS: U4.33 (PB12), U6.8 (~CS)
/PINIO1: U4.20 (PA4)
/PINIO2: U4.57 (PB5)
/PRESSURE_SENS: U4.8 (PC0); also elsewhere on the board
/SBUS: J5.6, J7.4, R36.1, U19.2
/SBUS_INV: R35.1, U4.26 (PB0), U19.1
/SDCARD_CS: J10.2 (DAT3/CD), U4.9 (PC1)
/SPI1_MISO: U4.56 (PB4), U5.1 (SDO), U6.11 (SDOUT)
/SPI1_MOSI: U4.23 (PA7), U5.14 (SDX), U6.9 (SDIN)
/SPI1_SCK: U4.21 (PA5), U5.13 (SCX), U6.10 (SCLK)
/SPI2_MISO: J10.7 (DAT0), U4.10 (PC2), U7.2 (DO/IO_{1})
/SPI2_MOSI: J10.3 (CMD), U4.11 (PC3), U7.5 (DI/IO_{0})
/SPI2_SCK: J10.5 (CLK), U4.34 (PB13), U7.6 (CLK)
/TIM1_CH1: U4.41 (PA8)
/TIM1_CH3N: J6.3, U4.36 (PB15)
/TIM2_CH1: J8.4, U4.50 (PA15)
/TIM2_CH2: J8.3, U4.55 (PB3)
/TIM2_CH3: J8.1, U4.29 (PB10)
/TIM2_CH4: J8.2, U4.30 (PB11)
/TIM3_CH4: U4.27 (PB1)
/TIM4_CH1: U4.58 (PB6)
/TIM8_CH3: J6.1, U4.39 (PC8)
/TIM8_CH4: J6.2, U4.40 (PC9)
/TIM9_CH2: U4.17 (PA3), U19.4
/TIM11_CH1: J6.4, U4.62 (PB9)
/TIM12_CH1: U4.35 (PB14)
/TIM13_CH1: U4.22 (PA6)
/UART4_RX: J5.4, J12.4, U4.15 (PA1)
/UART4_TX: J5.3, J12.3, U4.14 (PA0)
/UART5_RX: J3.4, U4.54 (PD2)
/UART5_TX: J3.3, U4.53 (PC12)
/USART1_RX: J9.4, U4.43 (PA10)
/USART1_TX: J9.3, U4.42 (PA9)
/USART2_TX: J7.3, U4.16 (PA2)
/USART3_RX: J6.6, J8.6, U4.52 (PC11)
/USART3_TX: U4.51 (PC10)
/USART6_RX: J4.5, U4.38 (PC7)
/USART6_TX: J4.4, U4.37 (PC6)
/USB_OTG_FS_DM: D2.2 (A2), J1.A7 (D-), J1.B7 (D-), U4.44 (PA11)
/USB_OTG_FS_DP: D4.2 (A2), J1.A6 (D+), J1.B6 (D+), U4.45 (PA12)
/VBUS: C9.1, C11.1, D1.2 (A2), D5.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
/VIDEO_IN: C3.2, J2.3, R17.2
/VIDEO_OUT: J4.1, R16.2
CAM_10V: C44.1, C45.1, J4.3, J5.1, L2.2, R19.2
Core_3V3: BOOT1.2, C1.1, C8.1, C14.1, C16.1, C18.1, C26.2, C29.2, C30.2, C31.2, C34.2, C35.2, C38.2, C39.2, C42.2, C43.2, D8.2 (A), R27.2, R31.1, R32.1, R33.1, U2.5 (VOUT), U4.1 (VBAT), U4.13 (VDDA), U4.19 (VDD), U4.32 (VDD), U4.48 (VDD), U4.64 (VDD), U5.5 (VDDIO), U5.8 (VDD), U6.3 (DVDD), U6.19 (~RESET), U6.21 (AVDD), U6.24 (PVDD), U8.6 (VDDIO), U8.8 (VDD), U19.5 (VCC), Y1.1 (Tri-State), Y1.4 (VDD)
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C18.2, C19.2, C20.2, C21.2, C23.2, C24.2, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.2, C45.2, D1.1 (A1), D2.1 (A1), D3.1 (A1), D4.1 (A1), H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.1, J2.MP (MountPin), J3.1, J3.MP (MountPin), J4.2, J4.MP (MountPin), J5.2, J5.5, J5.MP (MountPin), J6.8, J6.MP (MountPin), J7.1, J7.MP (MountPin), J8.8, J8.MP (MountPin), J9.1, J9.MP (MountPin), J10.6 (VSS), J10.9 (SHIELD), J12.1, J12.MP (MountPin), R1.1, R2.1, R7.2, R11.1, R15.2, R17.1, R18.1, R20.1, R21.1, R22.1, R28.2, R34.2, R35.2, R36.2, U1.5 (GND), U2.2 (GND), U3.2 (GND), U4.12 (VSSA), U4.18 (VSS), U4.63 (VSS), U5.6 (GNDIO), U5.7 (GND), U6.4 (DGND), U6.20 (AGND), U6.23 (PGND), U6.29, U7.4 (GND), U8.1 (GND), U8.7 (GND), U9.5 (GND), U19.3 (GND), Y1.2 (GND); also elsewhere on the board
unnamed: C10.2, C25.2, R16.1
unnamed: C17.1, R8.2
unnamed: C22.1, R10.2
unnamed: D6.2 (A), Q1.1 (G), R7.1
unnamed: C23.1, C24.1, D7.2 (A), L1.2, R13.2
unnamed: D8.1 (K), R20.2
unnamed: D9.1 (K), R21.2
unnamed: D10.1 (K), R22.2
unnamed: J1.A5 (CC1), R2.2
unnamed: J1.B5 (CC2), R1.2
unnamed: R9.2, R11.2, R13.1
unnamed: R12.2, R18.2, R19.1
unnamed: R8.1, U1.4 (BST)
unnamed: R3.2, U1.3 (EN/SYNC)
unnamed: R9.1, U1.1 (FB)
unnamed: R4.2, U1.8 (PG)
unnamed: C17.2, L1.1, U1.6 (SW)
unnamed: C7.1, R4.1, U1.2 (VCC)
unnamed: BOOT1.1, R28.1, U4.60 (BOOT0)
unnamed: R27.1, U4.7 (NRST)
unnamed: C37.2, U4.5 (PH0), Y1.3 (OUT)
unnamed: C27.2, U4.31 (VCAP_1)
unnamed: C28.2, U4.47 (VCAP_2)
unnamed: U6.5 (CLKIN), Y2.2
unnamed: C25.1, U6.25 (SAG)
unnamed: C3.1, U6.22 (VIN)
unnamed: C10.1, U6.26 (VOUT)
unnamed: U6.6 (XFB), Y2.1
unnamed: R30.1, U7.7 (~HOLD/~RESET/IO_{3})
unnamed: R29.1, U7.3 (~WP/IO_{2})
unnamed: R33.2, U8.2 (CSB)
unnamed: R34.1, U8.5 (SDO)
unnamed: R10.1, U9.4 (BST)
unnamed: R5.2, U9.3 (EN/SYNC)
unnamed: R12.1, U9.1 (FB)
unnamed: R6.2, U9.8 (PG)
unnamed: C22.2, L2.1, U9.6 (SW)
unnamed: C21.1, R6.1, U9.2 (VCC)
Periph_3V3: C15.1, C32.2, C33.2, C40.2, C41.2, J10.4 (VDD), R29.2, R30.2, U3.5 (VOUT), U7.8 (VCC)
System_4V5: C5.1, C6.1, D5.1 (K), D7.1 (K), J2.2, J3.2, J7.2, J9.2, J12.2, U2.1 (VIN), U2.3 (EN), U3.1 (VIN), U3.3 (EN); also elsewhere on the board
VCC_24V: C2.1, C4.1, C19.1, C20.1, D6.1 (K), Q1.2 (S), R3.1, R5.1, R14.1, TP1.1 (1_1), U1.7 (IN), U9.7 (IN)
VCC_BAT: C12.1, C13.1, D3.2 (A2), J6.7, J8.7, Q1.3 (D)

Notes on the sheet:
IMU
OSD
TF-SD-Card
MCU
3.3V 500mA MCU IMU Power
Flash
SBUS硬件反相电路
BAT power protection
Baro
BAT_Voltage_Detection
此处的电流一般不会超过5A
冲击保护
7.68kR 5V output
5V 3A output
green(B/E)
blue(ACT)
BAT power
10V 3A output
3.3V 500mA TF-Card QSPI OSD
Type-C power
防反接
red(3v3 Indicator)
LED指示灯
5V to Periph_VCC
5V to Core_VCC

Board: 4 copper layers, 35.8 x 45.8 mm, 124 parts (57 on the bottom side), 88 nets.

Other parts of the board:
J: pad; 1p_1.5mm_Pad
J#2, J#3, J#4, J#5: pad; 1p_1.5mm_Pad

Their connections:
/I2C1_SCL: J#3.1; also elsewhere on the board
/I2C1_SDA: J#2.1; also elsewhere on the board
/PRESSURE_SENS: J#4.1; also elsewhere on the board
GND: J.1; also elsewhere on the board
System_4V5: J#5.1; also elsewhere on the board

File production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BOOT1,3x2.5PushButton,1,TD-1183SN-1.5H(3x2.5),
"C1, C16, C18, C3",0402,4,0.1uF(0402),
C10,CP_Elec_6.3x7.7,1,100uF,
C11,0201,1,100nF(0201 16V 10%),
"C12, C13",0805,2,22uF(0805 35V 20%),
"C14, C15",0402,2,1uF(0402 10V 10%),
"C17, C22",0603,2,100nF(0603 25V 10%),
"C19, C2",0603,2,10uF(0603 35V 20%),
"C20, C4, C8",0402,3,1uF(0402 35V 10%),
"C21, C7",0603,2,100nF(0603 10V 10%),
"C23, C24, C25, C44, C45",0603,5,22uF(0603 16V),
C26,0603,1,100nF(0603 10.0V 10%),
"C27, C28",0402,2,2.2uF(0402 6.3V 10%),
C29,0402,1,4.7uF(0402 10V),
"C30, C31, C32, C33, C34, C35, C36, C38, C39, C40, C41, C42, C43",0402,13,100nF(0402 16.0V 10%),
C37,0603,1,15pF (0603 50V 5%),
"C5, C6, C9",0402,3,1uF(0402 16V 10%),
D1,PESD12VV1BL_315,1,PESD12VV1BL,
"D10, D9",0603,2,LED_blue,
"D2, D4",PESD5V0F1BL,2,PESD5V0F1BL,
D3,D_SOD-123F,1,SMF30CA(30V),
"D5, D7",D_SOD-123F,2,DSS34(3A 500mV),
D6,D_SOD-523,1,BZX584C9V1,
D8,0603,1,LED_Red,
"H1, H2, H3, H4",MountingHole_4.3mm_M4_DIN965_Pad,4,MountingHole_Pad,
"J_5, J_4, J_3, J_2, J",1p_1.5mm_Pad,5,pad,
J1,USB_C_Small,1,USB_C_Receptacle_USB2.0,
J10,TF-SMD_TF-021B-H265,1,Micro_SD_Card,
J12,01x04_MP_sh1.0_Hori,1,UART_4,
J2,01x03_MP_sh1.0_Hori,1,CAM,
J3,1x06-1MP_P1.00mm_Horizontal,1,GPS,
J4,01x05_MP_sh1.0_Hori,1,VTX,
J5,1x06-1MP_P1.00mm_Horizontal,1,DJI O4,
J6,01x08_MP_sh1.0_Hori,1,ESC,
J7,01x04_MP_sh1.0_Hori,1,Upper computer connector/RC input,
J8,01x08_MP_sh1.0_Hori,1,ESC_2,
J9,01x04_MP_sh1.0_Hori,1,USART_1,
"L1, L2",Inductor_0420,2,10uH(0420)(78438357100),
Q1,SOT-23,1,AP40P05,
"R1, R2",0201,2,5.1kR(0201),
"R10, R8",0603,2,20R(0603 25V),
R11,0603,1,7.68kR(0603 25V),
"R12, R9",0603,2,51kR(0603 25V),
"R13, R19",0603,2,41.2kR(0603 25V),
R14,0603,1,200.0kR(0603 50V 1%),
R15,0603,1,22.0kR(0603 50V 1%),
"R16, R17",0603,2,75R(0603 50V),
"R18, R20, R21, R22",0603,4,3.6kR(0603 25V),
"R27, R28, R29, R30, R31, R32, R33, R34, R35, R36",0603,10,10kR(0603),
"R3, R5",0402,2,1MR(0402 50V),
"R4, R6",0603,2,100kR(0603 25V),
R7,0603,1,100kR(0603 50V),
"U1, U9",MP9943GQ-Z,2,MP9943GQ-Z,
U19,DCK5,1,SN74LVC1G86DCKR,
"U2, U3",RT9013-33GB,2,RT9013-33GB,
U4,LQFP-64_10x10mm_P0.5mm,1,STM32F405RGTx,
U5,LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y,1,BMI270,
U6,HTSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP2.85x5.4mm,1,AT7456E,
U7,SOIC-8_5.3x5.3mm_P1.27mm,1,W25Q128JVS,
U8,Bosch_LGA-8_2x2.5mm_P0.65mm_ClockwisePinNumbering,1,SPL06,
Y1,Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm,1,YXC 0T252016MJBA4SL,
Y2,Crystal_SMD_5032-2Pin_5.0x3.2mm_HandSoldering,1,YXC_XG1EL89CSI-111YLC-27M 27MHz,
